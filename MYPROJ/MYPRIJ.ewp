# IAR project MYPRIJ.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; USER_DEBUG; STM32F10X_CL
  ICCARM.CCIncludePath2: src; oem\STM32F10x_StdPeriph_Lib_V3.3.0\Libraries\CMSIS\CM3\CoreSupport; oem\STM32F10x_StdPeriph_Lib_V3.3.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; oem\STM32F10x_StdPeriph_Lib_V3.3.0\Libraries\STM32F10x_StdPeriph_Driver\inc; oem\STM32F10x_StdPeriph_Lib_V3.3.0\Utilities\STM32_EVAL; oem\STM32F10x_StdPeriph_Lib_V3.3.0\Utilities\STM32_EVAL\STM3210C_EVAL; oem\STM32F10x_StdPeriph_Lib_V3.3.0\Utilities\STM32_EVAL\Common; oem\stm32 EFSL demo\efsl\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MYPRIJ.bin
  ILINK.IlinkOutputFile: MYPRIJ.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: MYPRIJ.srec
  ILINK.IlinkIcfFile: D:\PLK_KwonHJ\20180702_20180817InPLK\MYPROJ\make\stm32f10x_flash.icf
  group CMSIS
    oem/STM32F10x_StdPeriph_Lib_V3.3.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    oem/STM32F10x_StdPeriph_Lib_V3.3.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s
    oem/STM32F10x_StdPeriph_Lib_V3.3.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group src
    src/: button.c control.c delay.c flash.c gpio_set.c lcd.c main.c menu.c setup.c timer.c
  group StdPeriph
    oem/STM32F10x_StdPeriph_Lib_V3.3.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
